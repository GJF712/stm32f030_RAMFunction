# Keil uVision project project.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c include: ..\APP;..\BSP;..\CROWCONSTD;..\MODBUS\MASTER;..\MODBUS\SLAVE;..\STLIB\CMSIS\Device\ST\STM32F0xx\Include;..\STLIB\CMSIS\Include;..\STLIB\CMSIS\RTOS;..\STLIB\STM32F0xx_StdPeriph_Driver\inc;..\TASK;..\SCHEDULER\INTERRUPT;..\SCHEDULER\KERNEL;..\SCHEDULER\POLLING;..\MODBUS\SLAVE;..\MODBUS\MASTER
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\Objects\project.sct
  group App
    ../APP/: main.c stm32f0xx_it.c
    ./: readme.txt
  group StLibCMSIS
    ../STLIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../STLIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group StLibStdDri
    ../STLIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
